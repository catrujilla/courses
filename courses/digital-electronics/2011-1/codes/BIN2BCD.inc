;=======================================================================
;NOMBRE: TRANSF_BIN_BCD.INC
;PROYECTO: DIGITALCOUNTER
;AUTOR: NERIO ANDRES MONTOYA G -> INGENIERO FISICO
;FECHA: 13/06/2006

;RUTINA DEL RUSO, NIKOLAI GOLOVCHENKO, adapatada por Nerio Montoya
;http://www.piclist.com/techref/member/ng--944/index.htm
;
;ESTE ES EL MODULO ENCARGADO DE TRANSFORMAR EL NUMERO BINARIO DE 10 BIT
;EN UN NUMERO BCD REPRESENTADO EN TRES REGISTROS DE 8 BIT, ESTOS REGISTROS
;SON REGISTRO# (0,1,2). POSTERIORMENTE DE TENER CREADOS LOS TRES REGISTROS
;SE CREA CADA UNO DE LOS NUMEROS A SER REPRESENTADOS (LOS CUALES SERAN 
;LUEGO CAMBIADOS A VALOR PARA DISPLAY)
;
;ESTE PROGRAMA DEBE LLAMAR A LOS REGISTRO ADRESSH Y ADRESSL, LOS CUALES 
;DEBEN SER CARGADOS EN LOS REGISTROS H_BYTE Y L_BYTE
;=======================================================================

TRANSF_BIN_BCD

	;CALL	MATEMATICAS		;ESTA SUBRUTINA ES LLAMADA PARA ADECUAR EL DATO A LA ESCALA BINARIA QUE SE TIENE

	CLRF    REGISTRO0		;REINICIAR EL REGISTRO
	CLRF    REGISTRO1		;REINICIAR EL REGISTRO
	CLRF    REGISTRO2		;REINICIAR EL REGISTRO

	MOVF	RESULTADO_H,W	;CARGAR EL REGISTRO RESULTADO DEL ACONDICIONALMIENTO DEL DATO
	;MOVLW	B'00000110'		;VALOR PARA HACER PRUEBAS
	MOVWF	H_BYTE			;PARA SER TRANSFORMADO Y POSTERIORMENTE PRESENTADO
	MOVF	RESULTADO_L,W	;CARGAR EL REGISTRO RESULTADO DEL ACONDICIONALMIENTO DEL DATO
	;MOVLW	B'00100101'		;VALOR PARA HACER PRUEBAS
	MOVWF	L_BYTE			;PARA SER TRANSFORMADO Y POSTERIORMENTE PRESENTADO

	BCF     STATUS,C		;BORRA EL REGISTRO CARRY
	MOVLW   0x10			;ESTE ES EL VALOR DEL CONTADOR PARA EL PROCESO DE CONVERSION
	MOVWF   CONTADOR		;MOVER EL VALOR (16) AL REGISTRO CONTADOR
	GOTO	LOOP			;IR A LA RUTINA DE CONVERSION

LOOP
	RLF     L_BYTE,F		;RUTINA DE CONVERSION, DESCARGADA DE INTERNET... 
	RLF     H_BYTE,F		;FUNCIONA AUNQUE NO LA ENTIENDO
	RLF     REGISTRO2,F
	RLF     REGISTRO1,F
	RLF     REGISTRO0,F
	DECFSZ  CONTADOR,F
	GOTO    ADJ_DEC
	GOTO	CREAR_REGISTROS
	NOP
	RETURN

ADJ_DEC
	MOVLW   REGISTRO2
	MOVWF   FSR
	CAll    ADJ_BCD
	MOVLW   REGISTRO1
	MOVWF   FSR
	CAll    ADJ_BCD
	MOVLW   REGISTRO0
	MOVWF   FSR
	CAll    ADJ_BCD
	GOTO    LOOP

ADJ_BCD
	MOVLW   3
	ADDWF   INDF,W
	MOVWF   TEMP
	BTFSC   TEMP,3          
	MOVWF   INDF
	MOVLW   30
	ADDWF   INDF,W
	MOVWF   TEMP
	BTFSC   TEMP,7          
	MOVWF   INDF            
	RETURN
	
;ESTA ES LA RUTINA QUE CREA LOS VALORES DIGITALES EXTRAIDOS DE LOS REGISTROS#
;EN ESTA RUTINA SE CREAN 5 REGISTROS, CADA RESGISTRO ES UN NUMERO.
CREAR_REGISTROS
	MOVF	REGISTRO2,W
	ANDLW	0x0F
	MOVWF	UNIDAD
	SWAPF	REGISTRO2,W
	ANDLW	0x0F
	MOVWF	DECENA
	
	MOVF	REGISTRO1,W
	ANDLW	0x0F
	MOVWF	CENTENA
	SWAPF	REGISTRO1,W
	ANDLW	0x0F
	MOVWF	UNIDAD_MIL
	
	;MOVF	REGISTRO0,W
	;ANDLW	0x0F
	;MOVWF	UNIDAD_DIEZMIL
	RETURN

OBTENER_#ARAB
	ADDWF	PCL
	RETLW	D'48'		;ESCRIBIR 0 VIA SERIAL -> CODIFO ASCII
	RETLW	D'49'		;ESCRIBIR 1 VIA SERIAL -> CODIFO ASCII
	RETLW	D'50'		;ESCRIBIR 2 VIA SERIAL -> CODIFO ASCII
	RETLW	D'51'		;ESCRIBIR 3 VIA SERIAL -> CODIFO ASCII
	RETLW	D'52'		;ESCRIBIR 4 VIA SERIAL -> CODIFO ASCII
	RETLW	D'53'		;ESCRIBIR 5 VIA SERIAL -> CODIFO ASCII
	RETLW	D'54'		;ESCRIBIR 6 VIA SERIAL -> CODIFO ASCII
	RETLW	D'55'		;ESCRIBIR 7 VIA SERIAL -> CODIFO ASCII
	RETLW	D'56'		;ESCRIBIR 8 VIA SERIAL -> CODIFO ASCII
	RETLW	D'57'		;ESCRIBIR 9 VIA SERIAL -> CODIFO ASCII
